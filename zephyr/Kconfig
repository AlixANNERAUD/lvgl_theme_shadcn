## zephyr/Kconfig
```kconfig
config LV_THEME_SHADCN
	bool "Shadcn-inspired LVGL theme"
	depends on LVGL
	help
	  Build lvgl_theme_shadcn, a shadcn/ui-inspired theme for LVGL 9.6 or newer.
```
